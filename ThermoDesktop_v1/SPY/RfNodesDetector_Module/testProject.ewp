# IAR project testProject.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: testProject.srec
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: clk.c clk.h crc.c crc.h delay.c delay.h helper.c helper.h io_macros.h iostm8s105c6.h LEDs.c LEDs.h main.c rfm22.c rfm22.h rtc.c rtc.h spi.c spi.h types.h UartInt.c UartInt.h WirelessNetwork.c WirelessNetwork.h
